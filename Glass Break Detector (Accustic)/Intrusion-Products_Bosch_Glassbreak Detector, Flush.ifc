Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
File name: Projektnummer
Time: 2023-06-21T17:07:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 21 17:07:26 2023 * Host: LIS-C-001FN * Database: C:\Users\ROG2OVR\AppData\Local\Temp\{4C1C9FE3-B4CC-46A1-9A89-296396B70230}\ifc * Database version: 5507 * Database creation date: Wed Jun 21 17:07:25 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Jun 21 17:07:26 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 21 17:07:26 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 765625; RefLongitude: 13, 23, 59, 998626; RefElevation: 0 m
Other - Category: Project Information; Client Name: Bauherr; Project Address: Projektadresse; Project Issue Date: Projekt Datum; Project Name: Projektname; Project Number: Projektnummer; Project Status: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Bauherr; Project Address: Projektadresse; Project Issue Date: Projekt Datum; Project Name: Projektname; Project Number: Projektnummer; Project Status: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 m
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Ebene
Graphics(Type) - Color: 16711680; Line Pattern: Verdeckt; Line Weight: 1; Symbol: Beschriftung Ebene: Beschriftung Ebene; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 m
Dimensions - Computation Height: 0 m
Identity Data - Building Story: yes; Name: Ebene 0; Structural: no
Other - Category: Levels; Family: Level: Ebene; Family and Type: Level: Ebene; Type: Level: Ebene; Type Id: Level: Ebene

# IfcDistributionControlElement: Glassbreak Detector, Flush, Intrusion-Products_Bosch_Glassbreak Detector, Flush:Glassbreak_Detector_Flush:392714
In: Ebene 0
Type - PredefinedType: USERDEFINED; Classification: Pr_75_80_42_95 Vibration detectors (Uniclass 2015); Material: Xtech_Bosch_ABS
Type - Constraints - Default Elevation: 1.3 m
Type - Dimensions - 2DSymbolOffset: 0.005 m; Dimension depth (cm): 1.3; Dimension height (cm): 12; Dimension width (cm): 8.3
Type - General - Current consumption (mA): 21 mA; Effective Range: 7.6 m; Operating temperature (°C) (maximum): 49; Operating temperature (°C) (minimum): -29; Operating voltage (VDC) (maximum): 15; Operating voltage (VDC) (minimum): 9
Type - Identity Data - Description: Glassbreak Detector, Flush; Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; Family Version: 0; InstallationManual: https://resources-boschsecurity-cdn.azureedge.net/public/documents/fdf_Installation_Manual_enUS_81980681355.pdf; Manufacturer: Bosch Security and Safety Systems; OmniClass Number: 23.85.30.11; OmniClass Title: Access Controls; PlanningTools: NA; Product Information: https://resources-boschsecurity-cdn.azureedge.net/public/documents/DS1103i_Series_Data_sheet_enUS_2637311883.pdf; Product Website: https://commerce.boschsecurity.com/nordics/en/Glassbreak-detector-flush/p/4.998.800.268/; Type Name: Glassbreak_Detector_Flush
Type - Materials and Finishes - Color: White; Material: High‑impact ABS plastic enclosure
Type - Other - Category: Security Devices; Family Name: Intrusion-Products_Bosch_Glassbreak Detector, Flush
Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Constraints - Elevation: 0 m; Host: Level : Ebene 0; Level: Level: Ebene 0
Construction - Glassbreak Tester: yes
Dimensions - Volume: 0.0000440492 m3
Identity Data - CTN: DS1103I & DS1110I; Mark: 1; Material number: 4.998.800.268 & 4.998.800.270
Other - 2D_Flipped Position: yes; 2D_Original Position: no; Family: Intrusion-Products_Bosch_Glassbreak Detector, Flush: Glassbreak_Detector_Flush; Family and Type: Intrusion-Products_Bosch_Glassbreak Detector, Flush: Glassbreak_Detector_Flush; Schedule Level: Level: Ebene 0; Type: Intrusion-Products_Bosch_Glassbreak Detector, Flush: Glassbreak_Detector_Flush; Type Id: Intrusion-Products_Bosch_Glassbreak Detector, Flush: Glassbreak_Detector_Flush
Phasing - Phase Created: Phase 1
